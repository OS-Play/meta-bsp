
MODEL:playos-kvim = "khadas-vim"
